Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.0]
Time: 2023-12-29T12:39:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181217_1515(x64) - Exporter 19.2.0.65 - Альтернативный интерфейс 19.2.0.65
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 29 12:39:44 2023 * Host: 43-203-2 * Database: C:\Users\A8AC9~1.ZYA\AppData\Local\Temp\{D94FBF85-70BD-43A8-B486-071FF65C0362}\ifc * Database version: 5507 * Database creation date: Fri Dec 29 12:39:39 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Fri Dec 29 12:39:40 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 29 12:39:40 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2022
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - Reference: Сведения о проекте; NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2022
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее(Type) - Категория: Уровни; Имя семейства: Уровень
Идентификация(Type) - Имя типа: Отметка уровня с именем
Зависимости - Фасад: 0 mm
Идентификация - Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Прочее - Категория: Уровни; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm
Графика(Type) - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Зависимости(Type) - Базовая отметка: Базовая точка проекта

# IfcBuildingElementProxy: CA200750, De Dietrich_КотелПромышленныйСтальнойВодогрейныйДвуххотдовой_450-2000кВт:CA200750:722459
In: Этаж 01
Type - Material: De Dietrich_Серый_Буквы, De Dietrich_Графитово-серый_Условный, De Dietrich_Серый_Условный, De Dietrich_Темно-серый_Условный
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: De Dietrich; ADSK_Код изделия: CA200750; ADSK_Количество: 1; ADSK_Марка: CA R 750; ADSK_Масса_Текст: 1615; ADSK_Наименование: Котел стальной CA R 750, газовый/жидкотопливный, 750 кВт, наддувный (без панели управления)
Type - Идентификация - ADSK_URL документации изделия: https://www.dedietrich.ru/products/promyshlennoe_oborudovanie/stalnye_nadduvnye_kotly/ca_r/; ADSK_URL страницы изделия: https://www.dedietrich.ru/products/promyshlennoe_oborudovanie/stalnye_nadduvnye_kotly/ca_r/; ADSK_Версия Revit: 2019.1; ADSK_Версия семейства: 1.0; URL: https://www.dedietrich.ru/; Изготовитель: De Dietrich; Имя типа: CA200750; Описание: Котлы СA R — это стальные котлы с двухходовой топкой под избыточным давлением, с высоким КПД сгорания, для работы с жидкотопливными или газовыми надувными горелками.; Производитель_Контакты: тел: 8 800 333 17 18; email: info@dedietrich.ru; Разработчик_Контакты: support@bimlib.pro
Type - Материалы и отделка - Материал_1: De Dietrich_Графитово-серый_Условный; Материал_2: De Dietrich_Темно-серый_Условный; Материал_3: De Dietrich_Серый_Условный; Материал_4: De Dietrich_Серый_Буквы; Материал_Зона обслуживания: De Dietrich_ЗонаОбслуживания_Условный; Материал_УГО: De Dietrich_УГО_Белый_Условный
Type - Механизмы - ADSK_КПД: 92; ADSK_Температура обратной линии: 70 kg/K/s3; ADSK_Температура подающей линии: 115 kg/K/s3; Классификация: Нет; Объем воды: 0.89 m3
Type - Прочее - Категория: Оборудование; ADSK_Тепловая мощность: 750000 W; Имя семейства: De Dietrich_КотелПромышленныйСтальнойВодогрейныйДвуххотдовой_450-2000кВт; Надпись: 1
Type - Размеры - ADSK_Размер_Высота: 1315 mm; ADSK_Размер_Диаметр: 1205 mm; ADSK_Размер_Длина: 2890 mm; ADSK_Размер_Ширина: 1230 mm; B: 1230 mm; b1: 8 mm; d: 290 mm; H: 1315 mm; H1: 1265 mm; H2: 1010 mm; H3: 80 mm; H4: 660 mm; h штуцера: 49 mm; L: 2890 mm; L1: 2466 mm; L2: 145 mm; L3: 320 mm; L4: 1020 mm; L5: 350 mm; L6: 2244 mm; r1: 55 mm; r2: 102.5 mm; r3: 20 mm; r4: 72.5 mm; r5: 50 mm; r6: 25 mm; t1: 14 mm; t2: 12 mm; Газоход_Диаметр: 300 mm; Глазок_Высота: 933 mm; Глазок_Смещение_Горизонтальное: 0 mm; Дверца_Высота: 1008 mm; Дверца_Диаметр: 1164 mm; Дверца_Диаметр1: 1179 mm; Дверца_Диаметр2: 1144 mm; Длина надписи: 1350 mm; Дренаж_Высота: 80 mm; Дренаж_Диаметр: 20 mm; Дренаж_Длина: 160 mm; Дренаж_Расстояние: 100 mm; Надпись_Расстояние: 558 mm; Надпись_Смещение: 0 mm; Отверстие под горелку_Диаметр: 280 mm; Петля1_Смещение: 615 mm; Петля2_Смещение: 1200 mm; Плита_Толщина: 39 mm; Плита_Ширина: 390 mm; Подключение воды_Диаметр: 100 mm; ПредохранительныйКлапан_Диаметр: 40 mm; Рама_Высота: 100 mm; Слив конденсата_Диаметр: 15 mm; Тело_Диаметр: 1205 mm
Type - Текст - ADSK_Масса: 1615
Pset_BuildingElementProxyCommon - Reference: De Dietrich_КотелПромышленныйСтальнойВодогрейныйДвуххотдовой_450-2000кВт:CA200750; IsExternal: no
Pset_ManufacturerTypeInformation - Manufacturer: De Dietrich
Графика - ADSK_Зона обслуживания: no; УГО_Масштаб: 0.5; УГО_Сверху: yes; УГО_Слева: yes; УГО_Справа: yes
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 179
Механизмы - ADSK_Расход жидкости: 0 m3/s; Классификация систем: Не определено,Обратная жидкость,Приточная жидкость,Не определено
Прочее - Код типа: De Dietrich_КотелПромышленныйСтальнойВодогрейныйДвуххотдовой_450-2000кВт: CA200750; Семейство: De Dietrich_КотелПромышленныйСтальнойВодогрейныйДвуххотдовой_450-2000кВт: CA200750; Семейство и типоразмер: De Dietrich_КотелПромышленныйСтальнойВодогрейныйДвуххотдовой_450-2000кВт: CA200750; Тип: De Dietrich_КотелПромышленныйСтальнойВодогрейныйДвуххотдовой_450-2000кВт: CA200750
Размеры - Зона: 1 mm; Объем: 4.57253 m3; Площадь: 8.81217 m2
Стадии - Стадия возведения: Стадия 1

# IfcOpeningElement: Opening (4)
In: Этаж 01
PredefinedType: OPENING
Qto_OpeningElementBaseQuantities - Depth: 80 mm; Height: 30.8772 mm; Width: 20 mm
Pset_ManufacturerTypeInformation - Manufacturer: De Dietrich
Name (De Dietrich_КотелПромышленныйСтальнойВодогрейныйДвуххотдовой_450-2000кВт:CA200750:722459:...)
1
2
3
4
