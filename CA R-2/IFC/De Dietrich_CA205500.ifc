Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.0]
Time: 2023-12-29T12:53:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181217_1515(x64) - Exporter 19.2.0.65 - Альтернативный интерфейс 19.2.0.65
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 29 12:53:31 2023 * Host: 43-203-2 * Database: C:\Users\A8AC9~1.ZYA\AppData\Local\Temp\{8C1C405C-CCC1-47B6-9FCA-90FFD2A1DDAD}\ifc * Database version: 5507 * Database creation date: Fri Dec 29 12:53:28 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Fri Dec 29 12:53:29 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 29 12:53:29 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2022
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - Reference: Сведения о проекте; NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2022
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее(Type) - Категория: Уровни; Имя семейства: Уровень
Идентификация(Type) - Имя типа: Отметка уровня с именем
Зависимости - Фасад: 0 mm
Идентификация - Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Прочее - Категория: Уровни; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm
Графика(Type) - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Зависимости(Type) - Базовая отметка: Базовая точка проекта

# IfcBuildingElementProxy: CA205500, De Dietrich_КотелПромышленныйСтальнойВодогрейныйДвуххотдовой_2500-7000кВт:CA205500:710049
In: Этаж 01
Type - Material: De Dietrich_Серый_Буквы, De Dietrich_Графитово-серый_Условный, De Dietrich_Серый_Условный, De Dietrich_Темно-серый_Условный
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: De Dietrich; ADSK_Код изделия: CA205500; ADSK_Количество: 1; ADSK_Марка: CA R 5500; ADSK_Масса_Текст: 11082; ADSK_Наименование: Котел стальной CA R 5500, газовый/жидкотопливный, 5500 кВт, наддувный (без панели управления)
Type - Идентификация - ADSK_URL документации изделия: https://www.dedietrich.ru/products/promyshlennoe_oborudovanie/stalnye_nadduvnye_kotly/ca_r/; ADSK_URL страницы изделия: https://www.dedietrich.ru/products/promyshlennoe_oborudovanie/stalnye_nadduvnye_kotly/ca_r/; ADSK_Версия Revit: 2019.1; ADSK_Версия семейства: 1.0; URL: https://www.dedietrich.ru/; Изготовитель: De Dietrich; Имя типа: CA205500; Описание: Котлы СA R — это стальные котлы с двухходовой топкой под избыточным давлением, с высоким КПД сгорания, для работы с жидкотопливными или газовыми надувными горелками.; Производитель_Контакты: тел: 8 800 333 17 18; email: info@dedietrich.ru; Разработчик_Контакты: support@bimlib.pro
Type - Материалы и отделка - Материал_1: De Dietrich_Графитово-серый_Условный; Материал_2: De Dietrich_Темно-серый_Условный; Материал_3: De Dietrich_Серый_Условный; Материал_4: De Dietrich_Серый_Буквы; Материал_Зона обслуживания: De Dietrich_ЗонаОбслуживания_Условный; Материал_УГО: De Dietrich_УГО_Белый_Условный
Type - Механизмы - ADSK_КПД: 92; ADSK_Температура обратной линии: 70 kg/K/s3; ADSK_Температура подающей линии: 115 kg/K/s3; Классификация: Нет; Объем воды: 6.6 m3
Type - Прочее - Категория: Оборудование; ADSK_Тепловая мощность: 5500000 W; Имя семейства: De Dietrich_КотелПромышленныйСтальнойВодогрейныйДвуххотдовой_2500-7000кВт; Надпись: 4
Type - Размеры - ADSK_Размер_Высота: 2420 mm; ADSK_Размер_Диаметр: 2229 mm; ADSK_Размер_Длина: 5468 mm; ADSK_Размер_Ширина: 2254 mm; B: 2254 mm; b1: 8 mm; d: 620 mm; H: 2420 mm; H1: 2360 mm; H2: 1900 mm; H3: 110 mm; H4: 1226 mm; L: 5468 mm; L1: 4963 mm; L2: 203 mm; L3: 545 mm; L4: 1917 mm; L5: 500 mm; L6: 4530 mm; r1: 130 mm; r2: 185 mm; r3: 40 mm; r4: 97.5 mm; r5: 60 mm; r6: 25 mm; t1: 14 mm; t2: 12 mm; Газоход_Диаметр: 630 mm; Глазок_Высота: 1779 mm; Глазок_Смещение_Горизонтальное: 0 mm; Дверца_Высота: 1948 mm; Дверца_Диаметр: 2178 mm; Дверца_Диаметр1: 2193 mm; Дверца_Диаметр2: 2158 mm; Длина надписи: 3461 mm; Дренаж_Высота: 110 mm; Дренаж_Диаметр: 40 mm; Дренаж_Длина: 180 mm; Дренаж_Расстояние: 120 mm; Надпись_Расстояние: 751 mm; Надпись_Смещение: 0 mm; Отверстие под горелку_Диаметр: 580 mm; Петля1_Смещение: 1177 mm; Петля2_Смещение: 2350 mm; Плита_Толщина: 84 mm; Плита_Ширина: 830 mm; Подключение воды_Диаметр: 250 mm; ПредохранительныйКлапан_Диаметр: 80 mm; Рама_Высота: 120 mm; Слив конденсата_Диаметр: 15 mm; Тело_Диаметр: 2229 mm
Type - Текст - ADSK_Масса: 11082
Pset_BuildingElementProxyCommon - Reference: De Dietrich_КотелПромышленныйСтальнойВодогрейныйДвуххотдовой_2500-7000кВт:CA205500; IsExternal: no
Pset_ManufacturerTypeInformation - Manufacturer: De Dietrich
Графика - ADSK_Зона обслуживания: no; УГО_Масштаб: 0.5; УГО_Сверху: yes; УГО_Слева: yes; УГО_Справа: yes
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 161
Механизмы - ADSK_Расход жидкости: 0 m3/s; Классификация систем: Не определено,Обратная жидкость,Приточная жидкость
Прочее - Код типа: De Dietrich_КотелПромышленныйСтальнойВодогрейныйДвуххотдовой_2500-7000кВт: CA205500; Семейство: De Dietrich_КотелПромышленныйСтальнойВодогрейныйДвуххотдовой_2500-7000кВт: CA205500; Семейство и типоразмер: De Dietrich_КотелПромышленныйСтальнойВодогрейныйДвуххотдовой_2500-7000кВт: CA205500; Тип: De Dietrich_КотелПромышленныйСтальнойВодогрейныйДвуххотдовой_2500-7000кВт: CA205500
Размеры - Зона: 1 mm; Объем: 29.3571 m3; Площадь: 30.6101 m2
Стадии - Стадия возведения: Стадия 1

# IfcOpeningElement: Opening (4)
In: Этаж 01
PredefinedType: OPENING
Qto_OpeningElementBaseQuantities - Depth: 80 mm; Height: 79.1228 mm; Width: 20 mm
Pset_ManufacturerTypeInformation - Manufacturer: De Dietrich
Name (De Dietrich_КотелПромышленныйСтальнойВодогрейныйДвуххотдовой_2500-7000кВт:CA205500:710049:...)
1
2
3
4
