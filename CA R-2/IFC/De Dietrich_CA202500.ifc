Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.0]
Time: 2023-12-29T12:47:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181217_1515(x64) - Exporter 19.2.0.65 - Альтернативный интерфейс 19.2.0.65
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 29 12:47:55 2023 * Host: 43-203-2 * Database: C:\Users\A8AC9~1.ZYA\AppData\Local\Temp\{8A441C66-20E7-4526-96D4-64E1C7B32915}\ifc * Database version: 5507 * Database creation date: Fri Dec 29 12:47:51 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Fri Dec 29 12:47:52 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 29 12:47:52 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2022
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - Reference: Сведения о проекте; NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2022
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее(Type) - Категория: Уровни; Имя семейства: Уровень
Идентификация(Type) - Имя типа: Отметка уровня с именем
Зависимости(Type) - Базовая отметка: Базовая точка проекта
Зависимости - Фасад: 0 mm
Идентификация - Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Прочее - Категория: Уровни; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm
Графика(Type) - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680

# IfcBuildingElementProxy: 250, De Dietrich_Проставка приборов:250:734661
In: Этаж 01
Type - Material: De Dietrich_Серый_Условный
Type - Данные - ADSK_Единица измерения: комп.; ADSK_Завод-изготовитель: De Dietrich; ADSK_Код изделия: KITCA000250; ADSK_Количество: 0.5; ADSK_Марка: Проставка (катушка) KITCA000250; ADSK_Масса_Текст: 27,86 кг; ADSK_Наименование: Комплект катушек для установки датчиков ДУ 250 для CA R 5500-7000
Type - Идентификация - ADSK_URL документации изделия: https://www.dedietrich.ru/products/promyshlennoe_oborudovanie/; ADSK_URL страницы изделия: https://www.dedietrich.ru/products/promyshlennoe_oborudovanie/; ADSK_Версия Revit: 2019.1; ADSK_Версия семейства: 1.0; URL: https://www.dedietrich.ru/; Изготовитель: De Dietrich; Имя типа: 250; Производитель_Контакты: тел: 8 800 333 17 18; email: info@dedietrich.ru; Разработчик_Контакты: support@bimlib.pro
Type - Механизмы - Классификация: Нет
Type - Прочее - Категория: Оборудование; Имя семейства: De Dietrich_Проставка приборов
Type - Размеры - d: 273 mm; Dу: 250 mm; h1: 86 mm; h2: 100 mm; h3: 150 mm; L: 643 mm; r1: 136.5 mm; r2: 202.5 mm; t: 23 mm
Type - Текст - ADSK_Масса: 27.86
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: De Dietrich_Проставка приборов:250
Pset_ManufacturerTypeInformation - Manufacturer: De Dietrich
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 196
Материалы и отделка - Материал: De Dietrich_Серый_Условный
Механизмы - Классификация систем: Не определено
Прочее - Код типа: De Dietrich_Проставка приборов: 250; Семейство: De Dietrich_Проставка приборов: 250; Семейство и типоразмер: De Dietrich_Проставка приборов: 250; Тип: De Dietrich_Проставка приборов: 250
Размеры - Объем: 0.0211172 m3
Стадии - Стадия возведения: Стадия 1

# IfcBuildingElementProxy: CA202500, De Dietrich_КотелПромышленныйСтальнойВодогрейныйДвуххотдовой_2500-7000кВт:CA202500:709705
In: Этаж 01
Type - Material: De Dietrich_Серый_Буквы, De Dietrich_Графитово-серый_Условный, De Dietrich_Серый_Условный, De Dietrich_Темно-серый_Условный
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: De Dietrich; ADSK_Код изделия: CA202500; ADSK_Количество: 1; ADSK_Марка: CA R 2500; ADSK_Масса_Текст: 4375; ADSK_Наименование: Котел стальной CA R 2500, газовый/жидкотопливный, 2500 кВт, наддувный (без панели управления)
Type - Идентификация - ADSK_URL документации изделия: https://www.dedietrich.ru/products/promyshlennoe_oborudovanie/stalnye_nadduvnye_kotly/ca_r/; ADSK_URL страницы изделия: https://www.dedietrich.ru/products/promyshlennoe_oborudovanie/stalnye_nadduvnye_kotly/ca_r/; ADSK_Версия Revit: 2019.1; ADSK_Версия семейства: 1.0; URL: https://www.dedietrich.ru/; Изготовитель: De Dietrich; Имя типа: CA202500; Описание: Котлы СA R — это стальные котлы с двухходовой топкой под избыточным давлением, с высоким КПД сгорания, для работы с жидкотопливными или газовыми надувными горелками.; Производитель_Контакты: тел: 8 800 333 17 18; email: info@dedietrich.ru; Разработчик_Контакты: support@bimlib.pro
Type - Материалы и отделка - Материал_1: De Dietrich_Графитово-серый_Условный; Материал_2: De Dietrich_Темно-серый_Условный; Материал_3: De Dietrich_Серый_Условный; Материал_4: De Dietrich_Серый_Буквы; Материал_Зона обслуживания: De Dietrich_ЗонаОбслуживания_Условный; Материал_УГО: De Dietrich_УГО_Белый_Условный
Type - Механизмы - ADSK_КПД: 92; ADSK_Температура обратной линии: 70 kg/K/s3; ADSK_Температура подающей линии: 115 kg/K/s3; Классификация: Нет; Объем воды: 2.24 m3
Type - Прочее - Категория: Оборудование; ADSK_Тепловая мощность: 2500000 W; Имя семейства: De Dietrich_КотелПромышленныйСтальнойВодогрейныйДвуххотдовой_2500-7000кВт; Надпись: 3
Type - Размеры - ADSK_Размер_Высота: 1840 mm; ADSK_Размер_Диаметр: 1675 mm; ADSK_Размер_Длина: 3965 mm; ADSK_Размер_Ширина: 1700 mm; B: 1700 mm; b1: 8 mm; d: 440 mm; H: 1840 mm; H1: 1780 mm; H2: 1440 mm; H3: 90 mm; H4: 925 mm; L: 3965 mm; L1: 3480 mm; L2: 203 mm; L3: 355 mm; L4: 1358 mm; L5: 400 mm; L6: 3181 mm; r1: 80 mm; r2: 130 mm; r3: 32.5 mm; r4: 90 mm; r5: 60 mm; r6: 25 mm; t1: 14 mm; t2: 12 mm; Газоход_Диаметр: 450 mm; Глазок_Высота: 1320 mm; Глазок_Смещение_Горизонтальное: 0 mm; Дверца_Высота: 1395 mm; Дверца_Диаметр: 1590 mm; Дверца_Диаметр1: 1605 mm; Дверца_Диаметр2: 1570 mm; Длина надписи: 2660 mm; Дренаж_Высота: 90 mm; Дренаж_Диаметр: 25 mm; Дренаж_Длина: 180 mm; Дренаж_Расстояние: 100 mm; Надпись_Расстояние: 410 mm; Надпись_Смещение: 0 mm; Отверстие под горелку_Диаметр: 380 mm; Петля1_Смещение: 753 mm; Петля2_Смещение: 1900 mm; Плита_Толщина: 62 mm; Плита_Ширина: 580 mm; Подключение воды_Диаметр: 150 mm; ПредохранительныйКлапан_Диаметр: 65 mm; Рама_Высота: 120 mm; Слив конденсата_Диаметр: 15 mm; Тело_Диаметр: 1675 mm
Type - Текст - ADSK_Масса: 4375
Pset_BuildingElementProxyCommon - Reference: De Dietrich_КотелПромышленныйСтальнойВодогрейныйДвуххотдовой_2500-7000кВт:CA202500; IsExternal: no
Pset_ManufacturerTypeInformation - Manufacturer: De Dietrich
Графика - ADSK_Зона обслуживания: no; УГО_Масштаб: 0.5; УГО_Сверху: yes; УГО_Слева: yes; УГО_Справа: yes
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 155
Механизмы - ADSK_Расход жидкости: 0 m3/s; Классификация систем: Не определено,Обратная жидкость,Приточная жидкость
Прочее - Код типа: De Dietrich_КотелПромышленныйСтальнойВодогрейныйДвуххотдовой_2500-7000кВт: CA202500; Семейство: De Dietrich_КотелПромышленныйСтальнойВодогрейныйДвуххотдовой_2500-7000кВт: CA202500; Семейство и типоразмер: De Dietrich_КотелПромышленныйСтальнойВодогрейныйДвуххотдовой_2500-7000кВт: CA202500; Тип: De Dietrich_КотелПромышленныйСтальнойВодогрейныйДвуххотдовой_2500-7000кВт: CA202500
Размеры - Зона: 1 mm; Объем: 12.1961 m3; Площадь: 16.9305 m2
Стадии - Стадия возведения: Стадия 1

# IfcOpeningElement: Opening (4)
In: Этаж 01
PredefinedType: OPENING
Qto_OpeningElementBaseQuantities - Depth: 80 mm; Height: 60.7895 mm; Width: 20 mm
Pset_ManufacturerTypeInformation - Manufacturer: De Dietrich
Name (De Dietrich_КотелПромышленныйСтальнойВодогрейныйДвуххотдовой_2500-7000кВт:CA202500:709705:...)
1
2
3
4
