Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.0]
Time: 2023-12-29T12:56:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181217_1515(x64) - Exporter 19.2.0.65 - Альтернативный интерфейс 19.2.0.65
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 29 12:56:54 2023 * Host: 43-203-2 * Database: C:\Users\A8AC9~1.ZYA\AppData\Local\Temp\{830BBB8F-2646-4632-8A01-6D46AB5490DB}\ifc * Database version: 5507 * Database creation date: Fri Dec 29 12:56:53 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Fri Dec 29 12:56:54 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 29 12:56:54 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2022
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - Reference: Сведения о проекте; NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2022
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее(Type) - Категория: Уровни; Имя семейства: Уровень
Зависимости - Фасад: 0 mm
Идентификация - Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Прочее - Категория: Уровни; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm
Графика(Type) - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Зависимости(Type) - Базовая отметка: Базовая точка проекта
Идентификация(Type) - Имя типа: Отметка уровня с именем

# IfcBuildingElementProxy: De Dietrich_Стойка универсальная, De Dietrich_Стойка универсальная:De Dietrich_Стойка универсальная:786898
In: Этаж 01
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: De Dietrich; ADSK_Код изделия: CA100001; ADSK_Количество: 1; ADSK_Масса_Текст: 13,35; ADSK_Наименование: Стойка для крепления панелей универсальная
Type - Идентификация - URL: https://www.dedietrich.ru/; Изготовитель: De Dietrich; Имя типа: De Dietrich_Стойка универсальная
Type - Механизмы - Классификация: Нет
Type - Прочее - Категория: Оборудование; Имя семейства: De Dietrich_Стойка универсальная
Type - Размеры - Высота: 1700 mm; Ширина: 650 mm
Type - Текст - ADSK_Масса: 13.35
Pset_BuildingElementProxyCommon - Reference: De Dietrich_Стойка универсальная:De Dietrich_Стойка универсальная; IsExternal: no
Pset_ManufacturerTypeInformation - Manufacturer: De Dietrich
Зависимости - Основа: Уровень : Этаж 01; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Вариант конструкции: Главная модель; Марка: 200
Прочее - Код типа: De Dietrich_Стойка универсальная: De Dietrich_Стойка универсальная; Семейство: De Dietrich_Стойка универсальная: De Dietrich_Стойка универсальная; Семейство и типоразмер: De Dietrich_Стойка универсальная: De Dietrich_Стойка универсальная; Тип: De Dietrich_Стойка универсальная: De Dietrich_Стойка универсальная
Размеры - Объем: 0.0043993 m3; Площадь: 0.455843 m2
Стадии - Стадия возведения: Стадия 1
