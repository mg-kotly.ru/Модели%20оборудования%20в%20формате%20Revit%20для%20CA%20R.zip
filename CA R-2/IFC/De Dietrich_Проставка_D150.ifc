Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.0]
Time: 2023-12-29T13:01:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181217_1515(x64) - Exporter 19.2.0.65 - Альтернативный интерфейс 19.2.0.65
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 29 13:01:55 2023 * Host: 43-203-2 * Database: C:\Users\A8AC9~1.ZYA\AppData\Local\Temp\{D36E3169-0135-4784-BEAA-A1E33CDD426E}\ifc * Database version: 5507 * Database creation date: Fri Dec 29 13:01:54 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Fri Dec 29 13:01:54 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 29 13:01:54 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2022
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - Reference: Сведения о проекте; NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2022
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее(Type) - Категория: Уровни; Имя семейства: Уровень
Зависимости - Фасад: 0 mm
Идентификация - Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Прочее - Категория: Уровни; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm
Графика(Type) - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Зависимости(Type) - Базовая отметка: Базовая точка проекта
Идентификация(Type) - Имя типа: Отметка уровня с именем

# IfcBuildingElementProxy: 150, De Dietrich_Проставка приборов:150:734551
In: Этаж 01
Type - Material: De Dietrich_Серый_Условный
Type - Данные - ADSK_Единица измерения: комп.; ADSK_Завод-изготовитель: De Dietrich; ADSK_Код изделия: KITCA000150; ADSK_Количество: 0.5; ADSK_Марка: Проставка (катушка) KITCA000150; ADSK_Масса_Текст: 15,31 кг; ADSK_Наименование: Комплект катушек для установки датчиков ДУ 150 для CA R 1750-3500
Type - Идентификация - ADSK_URL документации изделия: https://www.dedietrich.ru/products/promyshlennoe_oborudovanie/; ADSK_URL страницы изделия: https://www.dedietrich.ru/products/promyshlennoe_oborudovanie/; ADSK_Версия Revit: 2019.1; ADSK_Версия семейства: 1.0; URL: https://www.dedietrich.ru/; Изготовитель: De Dietrich; Имя типа: 150; Производитель_Контакты: тел: 8 800 333 17 18; email: info@dedietrich.ru; Разработчик_Контакты: support@bimlib.pro
Type - Механизмы - Классификация: Нет
Type - Прочее - Категория: Оборудование; Имя семейства: De Dietrich_Проставка приборов
Type - Размеры - d: 159 mm; Dу: 150 mm; h1: 84 mm; h2: 100 mm; h3: 150 mm; L: 531 mm; r1: 79.5 mm; r2: 140 mm; t: 20 mm
Type - Текст - ADSK_Масса: 15.31
Pset_BuildingElementProxyCommon - Reference: De Dietrich_Проставка приборов:150; IsExternal: no
Pset_ManufacturerTypeInformation - Manufacturer: De Dietrich
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Watermark: Модели защищены уникальным кодом; Марка: 194
Материалы и отделка - Материал: De Dietrich_Серый_Условный
Механизмы - Классификация систем: Не определено
Прочее - Код типа: De Dietrich_Проставка приборов: 150; Семейство: De Dietrich_Проставка приборов: 150; Семейство и типоразмер: De Dietrich_Проставка приборов: 150; Тип: De Dietrich_Проставка приборов: 150
Размеры - Объем: 0.00795119 m3
Стадии - Стадия возведения: Стадия 1
